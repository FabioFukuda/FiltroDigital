# Keil uVision project ThreadX_Demo.uvprojx, settings and files
target ThreadX_Demo (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ThreadX_Demo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA2
  c include: .;.\ModifiedSource;..\..\ThreadX\common\inc;..\..\ThreadX\ports\cortex_m4\keil\inc;..\..\ARM\CMSIS\5.9.0\CMSIS\Core\Include;..\..\TivaWare_C_Series-2.2.0.295;.\src_other\display;..\..\TivaWare_C_Series-2.2.0.295\grlib
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --first __tx_vectors --entry=__main
  group ModifiedSource
    ./ModifiedSource/: TM4C1294NCPDT.h tx_initialize_low_level.s system_TM4C129.c startup_TM4C129.s
  group Library_Group
    ../../ThreadX/ports/cortex_m4/keil/example_build/: ThreadX_Library.lib
    ../../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    ../../TivaWare_C_Series-2.2.0.295/grlib/rvmdk/: grlib.lib
  group src_my
    ./: main.c menu.h menu.cpp menuTemplate.h menuTemplate.cpp
  group src_other
    ./: math_helper.c math_helper.h
    ./src_other/display/: Crystalfontz128x128_ST7735.c Crystalfontz128x128_ST7735.h HAL_EK_TM4C1294XL_Crystalfontz128x128_ST7735.c HAL_EK_TM4C1294XL_Crystalfontz128x128_ST7735.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0
